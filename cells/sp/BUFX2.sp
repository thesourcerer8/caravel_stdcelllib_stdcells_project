*** Spice netlist generated by cell2spice.pl from cell file BUFX2.cell ***

.subckt BUFX2 VPWR VGND A Y
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 Y 1 VPWR VPWR pmos w=0.840u l=0.150u
M2 1 A VGND VGND nmos w=0.420u l=0.150u
M3 Y 1 VGND VGND nmos w=0.420u l=0.150u
.ends BUFX2
