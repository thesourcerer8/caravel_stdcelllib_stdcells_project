*** Spice netlist generated by cell2spice.pl from cell file XOR2X1.cell ***

.subckt XOR2X1 vdd gnd B A Y
M0 1 A vdd vdd pmos w=0.840u l=0.150u
M1 3 2 vdd vdd pmos w=0.840u l=0.150u
M2 Y A 3 vdd pmos w=0.840u l=0.150u
M3 4 1 Y vdd pmos w=0.840u l=0.150u
M4 4 B vdd vdd pmos w=0.840u l=0.150u
M5 2 B vdd vdd pmos w=0.840u l=0.150u
M6 1 A gnd gnd nmos w=0.420u l=0.150u
M7 5 2 gnd gnd nmos w=0.420u l=0.150u
M8 Y 1 5 gnd nmos w=0.420u l=0.150u
M9 6 A Y gnd nmos w=0.420u l=0.150u
M10 6 B gnd gnd nmos w=0.420u l=0.150u
M11 2 B gnd gnd nmos w=0.420u l=0.150u
.ends XOR2X1
