*** Spice netlist generated by cell2spice.pl from cell file ASYNC3.cell ***

.subckt ASYNC3 VPWR VGND B A C CN
M0 CN B net2 VGND nmos w=0.420u l=0.150u
M1 net2 A GND VGND nmos w=0.420u l=0.150u
M2 CN A net1 VGND nmos w=0.420u l=0.150u
M3 C CN GND VGND nmos w=0.420u l=0.150u
M4 net1 B GND VGND nmos w=0.420u l=0.150u
M5 net2 C net1 VGND nmos w=0.420u l=0.150u
M6 CN B net3 VPWR pmos w=0.840u l=0.150u
M7 net3 A VDD VPWR pmos w=0.840u l=0.150u
M8 net4 B VDD VPWR pmos w=0.840u l=0.150u
M9 CN A net4 VPWR pmos w=0.840u l=0.150u
M10 C CN VDD VPWR pmos w=0.840u l=0.150u
M11 net4 C net3 VPWR pmos w=0.840u l=0.150u
.ends ASYNC3
