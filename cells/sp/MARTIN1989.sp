*** Spice netlist generated by cell2spice.pl from cell file MARTIN1989.cell ***

.subckt MARTIN1989 VPWR VGND A B C
M0 net2 B net3 VGND nmos w=0.420u l=0.150u
M1 net1 A VDD VPWR pmos w=0.840u l=0.150u
M2 net2 B net1 VPWR pmos w=0.840u l=0.150u
M3 C net2 VDD VPWR pmos w=0.840u l=0.150u
M4 net3 A GND VGND nmos w=0.420u l=0.150u
M5 C net2 GND VGND nmos w=0.420u l=0.150u
M6 net2 C VDD VPWR pmos w=0.840u l=0.150u
M7 net2 C GND VGND nmos w=0.420u l=0.150u
.ends MARTIN1989
