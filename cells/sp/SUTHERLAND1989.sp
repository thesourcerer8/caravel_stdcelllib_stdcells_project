*** Spice netlist generated by cell2spice.pl from cell file SUTHERLAND1989.cell ***

.subckt SUTHERLAND1989 VPWR VGND B A C
M0 net6 B net5 VGND nmos w=0.420u l=0.150u
M1 net2 A VDD VPWR pmos w=0.840u l=0.150u
M2 net6 B net2 VPWR pmos w=0.840u l=0.150u
M3 net1 A VDD VPWR pmos w=0.840u l=0.150u
M4 net1 B VDD VPWR pmos w=0.840u l=0.150u
M5 net3 C net1 VPWR pmos w=0.840u l=0.150u
M6 C net3 VDD VPWR pmos w=0.840u l=0.150u
M7 net3 C net4 VGND nmos w=0.420u l=0.150u
M8 net5 A GND VGND nmos w=0.420u l=0.150u
M9 net4 B GND VGND nmos w=0.420u l=0.150u
M10 net4 A GND VGND nmos w=0.420u l=0.150u
M11 C net3 GND VGND nmos w=0.420u l=0.150u
.ends SUTHERLAND1989
