*** Spice netlist generated by cell2spice.pl from cell file NAND2X1.cell ***

.subckt NAND2X1 VPWR VGND B A Y
M0 Y A VPWR VPWR pmos w=0.840u l=0.150u
M1 Y B VPWR VPWR pmos w=0.840u l=0.150u
M2 1 A VGND VGND nmos w=0.420u l=0.150u
M3 Y B 1 VGND nmos w=0.420u l=0.150u
.ends NAND2X1
