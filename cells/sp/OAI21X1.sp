*** Spice netlist generated by cell2spice.pl from cell file OAI21X1.cell ***

.subckt OAI21X1 VPWR VGND C B A Y
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 Y B 1 VPWR pmos w=0.840u l=0.150u
M2 Y C VPWR VPWR pmos w=0.840u l=0.150u
M3 2 A VGND VGND nmos w=0.420u l=0.150u
M4 2 B VGND VGND nmos w=0.420u l=0.150u
M5 Y C 2 VGND nmos w=0.420u l=0.150u
.ends OAI21X1
