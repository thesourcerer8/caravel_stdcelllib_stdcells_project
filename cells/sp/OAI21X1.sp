*** Spice netlist generated by cell2spice.pl from cell file OAI21X1.cell ***

.subckt OAI21X1 vdd gnd C B A Y
M0 1 A vdd vdd pmos w=0.840u l=0.150u
M1 Y B 1 vdd pmos w=0.840u l=0.150u
M2 Y C vdd vdd pmos w=0.840u l=0.150u
M3 2 A gnd gnd nmos w=0.420u l=0.150u
M4 2 B gnd gnd nmos w=0.420u l=0.150u
M5 Y C 2 gnd nmos w=0.420u l=0.150u
.ends OAI21X1
