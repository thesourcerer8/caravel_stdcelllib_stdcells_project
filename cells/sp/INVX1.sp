*** Spice netlist generated by cell2spice.pl from cell file INVX1.cell ***

.subckt INVX1 VPWR VGND A Y
M0 Y A VPWR VPWR pmos w=0.840u l=0.150u
M1 Y A VGND VGND nmos w=0.420u l=0.150u
.ends INVX1
