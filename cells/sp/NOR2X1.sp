*** Spice netlist generated by cell2spice.pl from cell file NOR2X1.cell ***

.subckt NOR2X1 vdd gnd B A Y
M0 1 A vdd vdd pmos w=0.840u l=0.150u
M1 Y B 1 vdd pmos w=0.840u l=0.150u
M2 Y A gnd gnd nmos w=0.420u l=0.150u
M3 Y B gnd gnd nmos w=0.420u l=0.150u
.ends NOR2X1
