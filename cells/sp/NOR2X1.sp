*** Spice netlist generated by cell2spice.pl from cell file NOR2X1.cell ***

.subckt NOR2X1 VPWR VGND B A Y
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 Y B 1 VPWR pmos w=0.840u l=0.150u
M2 Y A VGND VGND nmos w=0.420u l=0.150u
M3 Y B VGND VGND nmos w=0.420u l=0.150u
.ends NOR2X1
