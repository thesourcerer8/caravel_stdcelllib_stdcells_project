*** Spice netlist generated by cell2spice.pl from cell file VANBERKEL1991.cell ***

.subckt VANBERKEL1991 VPWR VGND A B C
M0 net3 B net5 VGND nmos w=0.420u l=0.150u
M1 net2 A VDD VPWR pmos w=0.840u l=0.150u
M2 net3 B net2 VPWR pmos w=0.840u l=0.150u
M3 net1 B VDD VPWR pmos w=0.840u l=0.150u
M4 net3 A net1 VPWR pmos w=0.840u l=0.150u
M5 C net3 VDD VPWR pmos w=0.840u l=0.150u
M6 net3 A net4 VGND nmos w=0.420u l=0.150u
M7 net5 A GND VGND nmos w=0.420u l=0.150u
M8 net4 B GND VGND nmos w=0.420u l=0.150u
M9 net4 C net5 VGND nmos w=0.420u l=0.150u
M10 C net3 GND VGND nmos w=0.420u l=0.150u
M11 net1 C net2 VPWR pmos w=0.840u l=0.150u
.ends VANBERKEL1991
