*** Spice netlist generated by cell2spice.pl ***

.subckt AND2X1 VPWR VGND B A Y
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 1 B VPWR VPWR pmos w=0.840u l=0.150u
M2 Y 1 VPWR VPWR pmos w=0.840u l=0.150u
M3 2 A 1 VGND nmos w=0.420u l=0.150u
M4 2 B VGND VGND nmos w=0.420u l=0.150u
M5 Y 1 VGND VGND nmos w=0.420u l=0.150u
.ends AND2X1

.subckt AND2X2 VPWR VGND B A Y
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 1 B VPWR VPWR pmos w=0.840u l=0.150u
M2 Y 1 VPWR VPWR pmos w=0.840u l=0.150u
M3 2 A 1 VGND nmos w=0.420u l=0.150u
M4 2 B VGND VGND nmos w=0.420u l=0.150u
M5 Y 1 VGND VGND nmos w=0.420u l=0.150u
.ends AND2X2

.subckt AOI21X1 VPWR VGND C B A Y
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 1 B VPWR VPWR pmos w=0.840u l=0.150u
M2 Y C 1 VPWR pmos w=0.840u l=0.150u
M3 2 A VGND VGND nmos w=0.420u l=0.150u
M4 Y B 2 VGND nmos w=0.420u l=0.150u
M5 Y C VGND VGND nmos w=0.420u l=0.150u
.ends AOI21X1

.subckt AOI22X1 VPWR VGND D C B A Y
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 1 B VPWR VPWR pmos w=0.840u l=0.150u
M2 Y D 1 VPWR pmos w=0.840u l=0.150u
M3 1 C Y VPWR pmos w=0.840u l=0.150u
M4 2 A VGND VGND nmos w=0.420u l=0.150u
M5 Y B 2 VGND nmos w=0.420u l=0.150u
M6 3 D Y VGND nmos w=0.420u l=0.150u
M7 3 C VGND VGND nmos w=0.420u l=0.150u
.ends AOI22X1

.subckt BUFX2 VPWR VGND A Y
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 Y 1 VPWR VPWR pmos w=0.840u l=0.150u
M2 1 A VGND VGND nmos w=0.420u l=0.150u
M3 Y 1 VGND VGND nmos w=0.420u l=0.150u
.ends BUFX2

.subckt BUFX4 VPWR VGND A Y
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 Y 1 VPWR VPWR pmos w=0.840u l=0.150u
M2 Y 1 VPWR VPWR pmos w=0.840u l=0.150u
M3 1 A VGND VGND nmos w=0.420u l=0.150u
M4 Y 1 VGND VGND nmos w=0.420u l=0.150u
M5 Y 1 VGND VGND nmos w=0.420u l=0.150u
.ends BUFX4

.subckt CLKBUF1 VPWR VGND A Y
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 1 A VPWR VPWR pmos w=0.840u l=0.150u
M2 2 1 VPWR VPWR pmos w=0.840u l=0.150u
M3 2 1 VPWR VPWR pmos w=0.840u l=0.150u
M4 3 2 VPWR VPWR pmos w=0.840u l=0.150u
M5 3 2 VPWR VPWR pmos w=0.840u l=0.150u
M6 Y 3 VPWR VPWR pmos w=0.840u l=0.150u
M7 Y 3 VPWR VPWR pmos w=0.840u l=0.150u
M8 1 A VGND VGND nmos w=0.420u l=0.150u
M9 1 A VGND VGND nmos w=0.420u l=0.150u
M10 2 1 VGND VGND nmos w=0.420u l=0.150u
M11 2 1 VGND VGND nmos w=0.420u l=0.150u
M12 3 2 VGND VGND nmos w=0.420u l=0.150u
M13 3 2 VGND VGND nmos w=0.420u l=0.150u
M14 Y 3 VGND VGND nmos w=0.420u l=0.150u
M15 Y 3 VGND VGND nmos w=0.420u l=0.150u
.ends CLKBUF1

.subckt CLKBUF2 VPWR VGND A Y
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 1 A VPWR VPWR pmos w=0.840u l=0.150u
M2 2 1 VPWR VPWR pmos w=0.840u l=0.150u
M3 2 1 VPWR VPWR pmos w=0.840u l=0.150u
M4 3 2 VPWR VPWR pmos w=0.840u l=0.150u
M5 3 2 VPWR VPWR pmos w=0.840u l=0.150u
M6 4 3 VPWR VPWR pmos w=0.840u l=0.150u
M7 4 3 VPWR VPWR pmos w=0.840u l=0.150u
M8 5 4 VPWR VPWR pmos w=0.840u l=0.150u
M9 5 4 VPWR VPWR pmos w=0.840u l=0.150u
M10 Y 5 VPWR VPWR pmos w=0.840u l=0.150u
M11 Y 5 VPWR VPWR pmos w=0.840u l=0.150u
M12 1 A VGND VGND nmos w=0.420u l=0.150u
M13 1 A VGND VGND nmos w=0.420u l=0.150u
M14 2 1 VGND VGND nmos w=0.420u l=0.150u
M15 2 1 VGND VGND nmos w=0.420u l=0.150u
M16 3 2 VGND VGND nmos w=0.420u l=0.150u
M17 3 2 VGND VGND nmos w=0.420u l=0.150u
M18 4 3 VGND VGND nmos w=0.420u l=0.150u
M19 4 3 VGND VGND nmos w=0.420u l=0.150u
M20 5 4 VGND VGND nmos w=0.420u l=0.150u
M21 5 4 VGND VGND nmos w=0.420u l=0.150u
M22 Y 5 VGND VGND nmos w=0.420u l=0.150u
M23 Y 5 VGND VGND nmos w=0.420u l=0.150u
.ends CLKBUF2

.subckt CLKBUF3 VPWR VGND A Y
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 1 A VPWR VPWR pmos w=0.840u l=0.150u
M2 2 1 VPWR VPWR pmos w=0.840u l=0.150u
M3 2 1 VPWR VPWR pmos w=0.840u l=0.150u
M4 3 2 VPWR VPWR pmos w=0.840u l=0.150u
M5 3 2 VPWR VPWR pmos w=0.840u l=0.150u
M6 4 3 VPWR VPWR pmos w=0.840u l=0.150u
M7 4 3 VPWR VPWR pmos w=0.840u l=0.150u
M8 5 4 VPWR VPWR pmos w=0.840u l=0.150u
M9 5 4 VPWR VPWR pmos w=0.840u l=0.150u
M10 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M11 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M12 7 6 VPWR VPWR pmos w=0.840u l=0.150u
M13 7 6 VPWR VPWR pmos w=0.840u l=0.150u
M14 Y 7 VPWR VPWR pmos w=0.840u l=0.150u
M15 Y 7 VPWR VPWR pmos w=0.840u l=0.150u
M16 1 A VGND VGND nmos w=0.420u l=0.150u
M17 1 A VGND VGND nmos w=0.420u l=0.150u
M18 2 1 VGND VGND nmos w=0.420u l=0.150u
M19 2 1 VGND VGND nmos w=0.420u l=0.150u
M20 3 2 VGND VGND nmos w=0.420u l=0.150u
M21 3 2 VGND VGND nmos w=0.420u l=0.150u
M22 4 3 VGND VGND nmos w=0.420u l=0.150u
M23 4 3 VGND VGND nmos w=0.420u l=0.150u
M24 5 4 VGND VGND nmos w=0.420u l=0.150u
M25 5 4 VGND VGND nmos w=0.420u l=0.150u
M26 6 5 VGND VGND nmos w=0.420u l=0.150u
M27 6 5 VGND VGND nmos w=0.420u l=0.150u
M28 7 6 VGND VGND nmos w=0.420u l=0.150u
M29 7 6 VGND VGND nmos w=0.420u l=0.150u
M30 Y 7 VGND VGND nmos w=0.420u l=0.150u
M31 Y 7 VGND VGND nmos w=0.420u l=0.150u
.ends CLKBUF3

.subckt DFFNEGX1 VPWR VGND D CLK Q
M0 1 CLK VPWR VPWR pmos w=0.840u l=0.150u
M1 2 D VPWR VPWR pmos w=0.840u l=0.150u
M2 3 1 2 VPWR pmos w=0.840u l=0.150u
M3 4 CLK 3 VPWR pmos w=0.840u l=0.150u
M4 4 5 VPWR VPWR pmos w=0.840u l=0.150u
M5 5 3 VPWR VPWR pmos w=0.840u l=0.150u
M6 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M7 7 CLK 6 VPWR pmos w=0.840u l=0.150u
M8 8 1 7 VPWR pmos w=0.840u l=0.150u
M9 8 Q VPWR VPWR pmos w=0.840u l=0.150u
M10 1 CLK VGND VGND nmos w=0.420u l=0.150u
M11 Q 7 VPWR VPWR pmos w=0.840u l=0.150u
M12 9 D VGND VGND nmos w=0.420u l=0.150u
M13 3 CLK 9 VGND nmos w=0.420u l=0.150u
M14 10 1 3 VGND nmos w=0.420u l=0.150u
M15 10 5 VGND VGND nmos w=0.420u l=0.150u
M16 5 3 VGND VGND nmos w=0.420u l=0.150u
M17 11 5 VGND VGND nmos w=0.420u l=0.150u
M18 7 1 11 VGND nmos w=0.420u l=0.150u
M19 12 CLK 7 VGND nmos w=0.420u l=0.150u
M20 12 Q VGND VGND nmos w=0.420u l=0.150u
M21 Q 7 VGND VGND nmos w=0.420u l=0.150u
.ends DFFNEGX1

.subckt DFFPOSX1 VPWR VGND D CLK Q
M0 1 CLK VPWR VPWR pmos w=0.840u l=0.150u
M1 2 D VPWR VPWR pmos w=0.840u l=0.150u
M2 3 CLK 2 VPWR pmos w=0.840u l=0.150u
M3 4 1 3 VPWR pmos w=0.840u l=0.150u
M4 4 5 VPWR VPWR pmos w=0.840u l=0.150u
M5 5 3 VPWR VPWR pmos w=0.840u l=0.150u
M6 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M7 7 1 6 VPWR pmos w=0.840u l=0.150u
M8 8 CLK 7 VPWR pmos w=0.840u l=0.150u
M9 8 Q VPWR VPWR pmos w=0.840u l=0.150u
M10 1 CLK VGND VGND nmos w=0.420u l=0.150u
M11 Q 7 VPWR VPWR pmos w=0.840u l=0.150u
M12 9 D VGND VGND nmos w=0.420u l=0.150u
M13 3 1 9 VGND nmos w=0.420u l=0.150u
M14 10 CLK 3 VGND nmos w=0.420u l=0.150u
M15 10 5 VGND VGND nmos w=0.420u l=0.150u
M16 5 3 VGND VGND nmos w=0.420u l=0.150u
M17 11 5 VGND VGND nmos w=0.420u l=0.150u
M18 7 CLK 11 VGND nmos w=0.420u l=0.150u
M19 12 1 7 VGND nmos w=0.420u l=0.150u
M20 12 Q VGND VGND nmos w=0.420u l=0.150u
M21 Q 7 VGND VGND nmos w=0.420u l=0.150u
.ends DFFPOSX1

.subckt DFFSR VPWR VGND S R D CLK Q
M0 1 R VPWR VPWR pmos w=0.840u l=0.150u
M1 1 2 VPWR VPWR pmos w=0.840u l=0.150u
M2 2 3 VPWR VPWR pmos w=0.840u l=0.150u
M3 2 S VPWR VPWR pmos w=0.840u l=0.150u
M4 3 4 1 VPWR pmos w=0.840u l=0.150u
M5 6 5 3 VPWR pmos w=0.840u l=0.150u
M6 6 D VPWR VPWR pmos w=0.840u l=0.150u
M7 5 4 VPWR VPWR pmos w=0.840u l=0.150u
M8 4 CLK VPWR VPWR pmos w=0.840u l=0.150u
M9 7 4 2 VPWR pmos w=0.840u l=0.150u
M10 8 5 7 VPWR pmos w=0.840u l=0.150u
M11 9 7 VPWR VPWR pmos w=0.840u l=0.150u
M12 9 R VPWR VPWR pmos w=0.840u l=0.150u
M13 8 9 VPWR VPWR pmos w=0.840u l=0.150u
M14 8 S VPWR VPWR pmos w=0.840u l=0.150u
M15 Q 9 VPWR VPWR pmos w=0.840u l=0.150u
M16 10 R 1 VGND nmos w=0.420u l=0.150u
M17 10 2 VGND VGND nmos w=0.420u l=0.150u
M18 11 3 VGND VGND nmos w=0.420u l=0.150u
M19 2 S 11 VGND nmos w=0.420u l=0.150u
M20 3 5 1 VGND nmos w=0.420u l=0.150u
M21 6 4 3 VGND nmos w=0.420u l=0.150u
M22 6 D VGND VGND nmos w=0.420u l=0.150u
M23 5 4 VGND VGND nmos w=0.420u l=0.150u
M24 4 CLK VGND VGND nmos w=0.420u l=0.150u
M25 7 5 2 VGND nmos w=0.420u l=0.150u
M26 8 4 7 VGND nmos w=0.420u l=0.150u
M27 12 7 9 VGND nmos w=0.420u l=0.150u
M28 12 R VGND VGND nmos w=0.420u l=0.150u
M29 13 9 VGND VGND nmos w=0.420u l=0.150u
M30 8 S 13 VGND nmos w=0.420u l=0.150u
M31 Q 9 VGND VGND nmos w=0.420u l=0.150u
.ends DFFSR

.subckt FAX1 VPWR VGND C B A YS YC
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 1 B VPWR VPWR pmos w=0.840u l=0.150u
M2 2 C 1 VPWR pmos w=0.840u l=0.150u
M3 3 B 2 VPWR pmos w=0.840u l=0.150u
M4 3 A VPWR VPWR pmos w=0.840u l=0.150u
M5 4 A VPWR VPWR pmos w=0.840u l=0.150u
M6 4 B VPWR VPWR pmos w=0.840u l=0.150u
M7 4 C VPWR VPWR pmos w=0.840u l=0.150u
M8 5 2 4 VPWR pmos w=0.840u l=0.150u
M9 6 C 5 VPWR pmos w=0.840u l=0.150u
M10 7 B 6 VPWR pmos w=0.840u l=0.150u
M11 7 A VPWR VPWR pmos w=0.840u l=0.150u
M12 YS 5 VPWR VPWR pmos w=0.840u l=0.150u
M13 YC 2 VPWR VPWR pmos w=0.840u l=0.150u
M14 8 A VGND VGND nmos w=0.420u l=0.150u
M15 8 B VGND VGND nmos w=0.420u l=0.150u
M16 2 C 8 VGND nmos w=0.420u l=0.150u
M17 9 B 2 VGND nmos w=0.420u l=0.150u
M18 9 A VGND VGND nmos w=0.420u l=0.150u
M19 10 A VGND VGND nmos w=0.420u l=0.150u
M20 10 B VGND VGND nmos w=0.420u l=0.150u
M21 10 C VGND VGND nmos w=0.420u l=0.150u
M22 5 2 10 VGND nmos w=0.420u l=0.150u
M23 11 C 5 VGND nmos w=0.420u l=0.150u
M24 12 B 11 VGND nmos w=0.420u l=0.150u
M25 12 A VGND VGND nmos w=0.420u l=0.150u
M26 YS 5 VGND VGND nmos w=0.420u l=0.150u
M27 YC 2 VGND VGND nmos w=0.420u l=0.150u
.ends FAX1

.subckt HAX1 VPWR VGND B A YS YC
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 1 B VPWR VPWR pmos w=0.840u l=0.150u
M2 YC 1 VPWR VPWR pmos w=0.840u l=0.150u
M3 2 1 VPWR VPWR pmos w=0.840u l=0.150u
M4 3 B 2 VPWR pmos w=0.840u l=0.150u
M5 3 A VPWR VPWR pmos w=0.840u l=0.150u
M6 YS 2 VPWR VPWR pmos w=0.840u l=0.150u
M7 4 A VGND VGND nmos w=0.420u l=0.150u
M8 1 B 4 VGND nmos w=0.420u l=0.150u
M9 YC 1 VGND VGND nmos w=0.420u l=0.150u
M10 5 1 VGND VGND nmos w=0.420u l=0.150u
M11 2 B 5 VGND nmos w=0.420u l=0.150u
M12 5 A 2 VGND nmos w=0.420u l=0.150u
M13 YS 2 VGND VGND nmos w=0.420u l=0.150u
.ends HAX1

.subckt INV VPWR VGND A Y
M0 Y A VPWR VPWR pmos w=0.840u l=0.150u
M1 Y A VGND VGND nmos w=0.420u l=0.150u
.ends INV

.subckt INVX1 VPWR VGND A Y
M0 Y A VPWR VPWR pmos w=0.840u l=0.150u
M1 Y A VGND VGND nmos w=0.420u l=0.150u
.ends INVX1

.subckt INVX2 VPWR VGND A Y
M0 Y A VPWR VPWR pmos w=0.840u l=0.150u
M1 Y A VGND VGND nmos w=0.420u l=0.150u
.ends INVX2

.subckt INVX4 VPWR VGND A Y
M0 Y A VPWR VPWR pmos w=0.840u l=0.150u
M1 Y A VPWR VPWR pmos w=0.840u l=0.150u
M2 Y A VGND VGND nmos w=0.420u l=0.150u
M3 Y A VGND VGND nmos w=0.420u l=0.150u
.ends INVX4

.subckt INVX8 VPWR VGND A Y
M0 Y A VPWR VPWR pmos w=0.840u l=0.150u
M1 Y A VPWR VPWR pmos w=0.840u l=0.150u
M2 Y A VPWR VPWR pmos w=0.840u l=0.150u
M3 Y A VPWR VPWR pmos w=0.840u l=0.150u
M4 Y A VGND VGND nmos w=0.420u l=0.150u
M5 Y A VGND VGND nmos w=0.420u l=0.150u
M6 Y A VGND VGND nmos w=0.420u l=0.150u
M7 Y A VGND VGND nmos w=0.420u l=0.150u
.ends INVX8

.subckt LATCH VPWR VGND D CLK Q
M0 1 CLK VPWR VPWR pmos w=0.840u l=0.150u
M1 2 D VPWR VPWR pmos w=0.840u l=0.150u
M2 3 1 2 VPWR pmos w=0.840u l=0.150u
M3 4 CLK 3 VPWR pmos w=0.840u l=0.150u
M4 4 Q VPWR VPWR pmos w=0.840u l=0.150u
M5 1 CLK VGND VGND nmos w=0.420u l=0.150u
M6 Q 3 VPWR VPWR pmos w=0.840u l=0.150u
M7 5 D VGND VGND nmos w=0.420u l=0.150u
M8 3 CLK 5 VGND nmos w=0.420u l=0.150u
M9 6 1 3 VGND nmos w=0.420u l=0.150u
M10 6 Q VGND VGND nmos w=0.420u l=0.150u
M11 Q 3 VGND VGND nmos w=0.420u l=0.150u
.ends LATCH

.subckt LOFTY VPWR VGND asel_p asel_n bsel_p bsel_n muxsel_p muxsel_n usexor_p usexor_n usemux_p usemux_n q
M0 q usemux_p N0 VGND nmos w=0.420u l=0.150u
M1 q usemux_n N1 VGND nmos w=0.420u l=0.150u
M2 N0 asel_p N00 VGND nmos w=0.420u l=0.150u
M3 N0 asel_n N01 VGND nmos w=0.420u l=0.150u
M4 N00 usexor_p VGND VGND nmos w=0.420u l=0.150u
M5 N00 usexor_n N001 VGND nmos w=0.420u l=0.150u
M6 N001 bsel_p VGND VGND nmos w=0.420u l=0.150u
M7 N011 bsel_n VGND VGND nmos w=0.420u l=0.150u
M8 N01 usexor_p N001 VGND nmos w=0.420u l=0.150u
M9 N01 usexor_n N011 VGND nmos w=0.420u l=0.150u
M10 N1 muxsel_n N001 VGND nmos w=0.420u l=0.150u
M11 N1 muxsel_p N10 VGND nmos w=0.420u l=0.150u
M12 N10 asel_p VGND VGND nmos w=0.420u l=0.150u
M13 P0 usemux_n q VPWR pmos w=0.840u l=0.150u
M14 P1 usemux_p q VPWR pmos w=0.840u l=0.150u
M15 P00 asel_n P0 VPWR pmos w=0.840u l=0.150u
M16 P01 asel_p P0 VPWR pmos w=0.840u l=0.150u
M17 P001 usexor_p P00 VPWR pmos w=0.840u l=0.150u
M18 vcc bsel_p P001 VPWR pmos w=0.840u l=0.150u
M19 P001 usexor_n P01 VPWR pmos w=0.840u l=0.150u
M20 P011 usexor_p P01 VPWR pmos w=0.840u l=0.150u
M21 vcc bsel_n P011 VPWR pmos w=0.840u l=0.150u
M22 P001 muxsel_p P1 VPWR pmos w=0.840u l=0.150u
M23 P10 muxsel_n P1 VPWR pmos w=0.840u l=0.150u
M24 vcc asel_p P10 VPWR pmos w=0.840u l=0.150u
.ends LOFTY

.subckt LOFTY2 VPWR VGND usemux_p muxsel_p asel_p usexor_p bsel_p usemux_n muxsel_n asel_n usexor_n bsel_n q
M0 usemux_n usemux_p VPWR VPWR pmos w=0.840u l=0.150u
M1 usemux_n usemux_p VGND VGND nmos w=0.420u l=0.150u
M2 muxsel_n muxsel_p VPWR VPWR pmos w=0.840u l=0.150u
M3 muxsel_n muxsel_p VGND VGND nmos w=0.420u l=0.150u
M4 asel_n asel_p VPWR VPWR pmos w=0.840u l=0.150u
M5 asel_n asel_p VGND VGND nmos w=0.420u l=0.150u
M6 usexor_n usexor_p VPWR VPWR pmos w=0.840u l=0.150u
M7 usexor_n usexor_p VGND VGND nmos w=0.420u l=0.150u
M8 bsel_n bsel_p VPWR VPWR pmos w=0.840u l=0.150u
M9 bsel_n bsel_p VGND VGND nmos w=0.420u l=0.150u
M10 q usemux_n usemux0n VGND nmos w=0.420u l=0.150u
M11 usemux0p usemux_p q VPWR pmos w=0.840u l=0.150u
M12 q usemux_p usemux1n VGND nmos w=0.420u l=0.150u
M13 usemux1p usemux_n q VPWR pmos w=0.840u l=0.150u
M14 usemux1n muxsel_p usemux1muxsel1n VGND nmos w=0.420u l=0.150u
M15 usemux1muxsel1p muxsel_n usemux1p VPWR pmos w=0.840u l=0.150u
M16 usemux1n muxsel_n usemux1muxsel0n VGND nmos w=0.420u l=0.150u
M17 usemux1muxsel0p muxsel_p usemux1p VPWR pmos w=0.840u l=0.150u
M18 usemux1muxsel0n asel_n VGND VGND nmos w=0.420u l=0.150u
M19 VPWR asel_n usemux1muxsel0p VPWR pmos w=0.840u l=0.150u
M20 usemux1muxsel1n bsel_n VGND VGND nmos w=0.420u l=0.150u
M21 VPWR bsel_n usemux1muxsel1p VPWR pmos w=0.840u l=0.150u
M22 usemux0n asel_n usemux0asel0n VGND nmos w=0.420u l=0.150u
M23 usemux0asel0p asel_p usemux0p VPWR pmos w=0.840u l=0.150u
M24 usemux0n asel_p usemux0asel1n VGND nmos w=0.420u l=0.150u
M25 usemux0asel1p asel_n usemux0p VPWR pmos w=0.840u l=0.150u
M26 usemux0asel1n usexor_n usemux1muxsel1n VGND nmos w=0.420u l=0.150u
M27 usemux1muxsel1p usexor_p usemux0asel1p VPWR pmos w=0.840u l=0.150u
M28 usemux0asel1n usexor_p usemux1muxsel1usexor1n VGND nmos w=0.420u l=0.150u
M29 usemux1muxsel1usexor1p usexor_n usemux0asel1p VPWR pmos w=0.840u l=0.150u
M30 usemux1muxsel1usexor1n bsel_p VGND VGND nmos w=0.420u l=0.150u
M31 VPWR bsel_p usemux1muxsel1usexor1p VPWR pmos w=0.840u l=0.150u
M32 usemux0asel0n usexor_n VGND VGND nmos w=0.420u l=0.150u
M33 usemux0asel0n usexor_p usemux1muxsel1n VGND nmos w=0.420u l=0.150u
M34 usemux1muxsel1p usexor_n usemux0asel0p VPWR pmos w=0.840u l=0.150u
.ends LOFTY2

.subckt MUX2X1 VPWR VGND S B A Y
M0 1 S VPWR VPWR pmos w=0.840u l=0.150u
M1 2 B VPWR VPWR pmos w=0.840u l=0.150u
M2 Y S 2 VPWR pmos w=0.840u l=0.150u
M3 3 1 Y VPWR pmos w=0.840u l=0.150u
M4 3 A VPWR VPWR pmos w=0.840u l=0.150u
M5 1 S VGND VGND nmos w=0.420u l=0.150u
M6 4 B VGND VGND nmos w=0.420u l=0.150u
M7 Y 1 4 VGND nmos w=0.420u l=0.150u
M8 5 S Y VGND nmos w=0.420u l=0.150u
M9 5 A VGND VGND nmos w=0.420u l=0.150u
.ends MUX2X1

.subckt NAND2X1 VPWR VGND B A Y
M0 Y A VPWR VPWR pmos w=0.840u l=0.150u
M1 Y B VPWR VPWR pmos w=0.840u l=0.150u
M2 1 A VGND VGND nmos w=0.420u l=0.150u
M3 Y B 1 VGND nmos w=0.420u l=0.150u
.ends NAND2X1

.subckt NAND3X1 VPWR VGND C B A Y
M0 Y A VPWR VPWR pmos w=0.840u l=0.150u
M1 Y B VPWR VPWR pmos w=0.840u l=0.150u
M2 Y C VPWR VPWR pmos w=0.840u l=0.150u
M3 1 A VGND VGND nmos w=0.420u l=0.150u
M4 2 B 1 VGND nmos w=0.420u l=0.150u
M5 Y C 2 VGND nmos w=0.420u l=0.150u
.ends NAND3X1

.subckt NOR2X1 VPWR VGND B A Y
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 Y B 1 VPWR pmos w=0.840u l=0.150u
M2 Y A VGND VGND nmos w=0.420u l=0.150u
M3 Y B VGND VGND nmos w=0.420u l=0.150u
.ends NOR2X1

.subckt NOR3X1 VPWR VGND C B A Y
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 1 A VPWR VPWR pmos w=0.840u l=0.150u
M2 2 B 1 VPWR pmos w=0.840u l=0.150u
M3 1 B 2 VPWR pmos w=0.840u l=0.150u
M4 Y C 2 VPWR pmos w=0.840u l=0.150u
M5 2 C Y VPWR pmos w=0.840u l=0.150u
M6 Y A VGND VGND nmos w=0.420u l=0.150u
M7 Y B VGND VGND nmos w=0.420u l=0.150u
M8 Y C VGND VGND nmos w=0.420u l=0.150u
.ends NOR3X1

.subckt OAI21X1 VPWR VGND C B A Y
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 Y B 1 VPWR pmos w=0.840u l=0.150u
M2 Y C VPWR VPWR pmos w=0.840u l=0.150u
M3 2 A VGND VGND nmos w=0.420u l=0.150u
M4 2 B VGND VGND nmos w=0.420u l=0.150u
M5 Y C 2 VGND nmos w=0.420u l=0.150u
.ends OAI21X1

.subckt OAI22X1 VPWR VGND D C B A Y
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 Y B 1 VPWR pmos w=0.840u l=0.150u
M2 2 D Y VPWR pmos w=0.840u l=0.150u
M3 2 C VPWR VPWR pmos w=0.840u l=0.150u
M4 3 A VGND VGND nmos w=0.420u l=0.150u
M5 3 B VGND VGND nmos w=0.420u l=0.150u
M6 Y D 3 VGND nmos w=0.420u l=0.150u
M7 3 C Y VGND nmos w=0.420u l=0.150u
.ends OAI22X1

.subckt OR2X1 VPWR VGND B A Y
M0 1 A 2 VPWR pmos w=0.840u l=0.150u
M1 1 B VPWR VPWR pmos w=0.840u l=0.150u
M2 Y 2 VPWR VPWR pmos w=0.840u l=0.150u
M3 2 A VGND VGND nmos w=0.420u l=0.150u
M4 2 B VGND VGND nmos w=0.420u l=0.150u
M5 Y 2 VGND VGND nmos w=0.420u l=0.150u
.ends OR2X1

.subckt OR2X2 VPWR VGND B A Y
M0 1 A 2 VPWR pmos w=0.840u l=0.150u
M1 1 B VPWR VPWR pmos w=0.840u l=0.150u
M2 Y 2 VPWR VPWR pmos w=0.840u l=0.150u
M3 2 A VGND VGND nmos w=0.420u l=0.150u
M4 2 B VGND VGND nmos w=0.420u l=0.150u
M5 Y 2 VGND VGND nmos w=0.420u l=0.150u
.ends OR2X2

.subckt PADINC VPWR VGND DI YPAD
M0 vdd2 1 YPAD VPWR pmos w=0.840u l=0.150u
M1 YPAD 1 vdd2 VPWR pmos w=0.840u l=0.150u
M2 vdd2 1 YPAD VPWR pmos w=0.840u l=0.150u
M3 YPAD 1 vdd2 VPWR pmos w=0.840u l=0.150u
M4 vdd2 1 YPAD VPWR pmos w=0.840u l=0.150u
M5 YPAD 1 vdd2 VPWR pmos w=0.840u l=0.150u
M6 vdd2 1 YPAD VPWR pmos w=0.840u l=0.150u
M7 YPAD 1 vdd2 VPWR pmos w=0.840u l=0.150u
M8 vdd2 1 YPAD VPWR pmos w=0.840u l=0.150u
M9 YPAD 1 vdd2 VPWR pmos w=0.840u l=0.150u
M10 vdd2 1 YPAD VPWR pmos w=0.840u l=0.150u
M11 YPAD 1 vdd2 VPWR pmos w=0.840u l=0.150u
M12 2 gnd2 VGND VGND nmos w=0.420u l=0.150u
M13 3 2 VGND VGND nmos w=0.420u l=0.150u
M14 4 gnd2 VGND VGND nmos w=0.420u l=0.150u
M15 4 gnd2 VGND VGND nmos w=0.420u l=0.150u
M16 4 gnd2 VGND VGND nmos w=0.420u l=0.150u
M17 4 gnd2 VGND VGND nmos w=0.420u l=0.150u
M18 4 gnd2 VGND VGND nmos w=0.420u l=0.150u
M19 4 2 VGND VGND nmos w=0.420u l=0.150u
M20 4 2 VGND VGND nmos w=0.420u l=0.150u
M21 4 2 VGND VGND nmos w=0.420u l=0.150u
M22 4 2 VGND VGND nmos w=0.420u l=0.150u
M23 4 2 VGND VGND nmos w=0.420u l=0.150u
M24 1 3 4 VGND nmos w=0.420u l=0.150u
M25 4 3 1 VGND nmos w=0.420u l=0.150u
M26 1 3 4 VGND nmos w=0.420u l=0.150u
M27 4 3 1 VGND nmos w=0.420u l=0.150u
M28 6 5 VGND VGND nmos w=0.420u l=0.150u
M29 6 5 VGND VGND nmos w=0.420u l=0.150u
M30 6 5 VGND VGND nmos w=0.420u l=0.150u
M31 6 5 VGND VGND nmos w=0.420u l=0.150u
M32 6 5 VGND VGND nmos w=0.420u l=0.150u
M33 6 5 VGND VGND nmos w=0.420u l=0.150u
M34 DI 6 VGND VGND nmos w=0.420u l=0.150u
M35 DI 6 VGND VGND nmos w=0.420u l=0.150u
M36 DI 6 VGND VGND nmos w=0.420u l=0.150u
M37 DI 6 VGND VGND nmos w=0.420u l=0.150u
M38 DI 6 VGND VGND nmos w=0.420u l=0.150u
M39 DI 6 VGND VGND nmos w=0.420u l=0.150u
M40 2 gnd2 VPWR VPWR pmos w=0.840u l=0.150u
M41 3 2 VPWR VPWR pmos w=0.840u l=0.150u
M42 1 gnd2 VPWR VPWR pmos w=0.840u l=0.150u
M43 1 gnd2 VPWR VPWR pmos w=0.840u l=0.150u
M44 1 gnd2 VPWR VPWR pmos w=0.840u l=0.150u
M45 1 gnd2 VPWR VPWR pmos w=0.840u l=0.150u
M46 1 gnd2 VPWR VPWR pmos w=0.840u l=0.150u
M47 1 3 VPWR VPWR pmos w=0.840u l=0.150u
M48 1 3 VPWR VPWR pmos w=0.840u l=0.150u
M49 1 3 VPWR VPWR pmos w=0.840u l=0.150u
M50 1 3 VPWR VPWR pmos w=0.840u l=0.150u
M51 1 3 VPWR VPWR pmos w=0.840u l=0.150u
M52 4 2 1 VPWR pmos w=0.840u l=0.150u
M53 1 2 4 VPWR pmos w=0.840u l=0.150u
M54 4 2 1 VPWR pmos w=0.840u l=0.150u
M55 1 2 4 VPWR pmos w=0.840u l=0.150u
M56 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M57 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M58 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M59 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M60 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M61 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M62 DI 6 VPWR VPWR pmos w=0.840u l=0.150u
M63 DI 6 VPWR VPWR pmos w=0.840u l=0.150u
M64 DI 6 VPWR VPWR pmos w=0.840u l=0.150u
M65 DI 6 VPWR VPWR pmos w=0.840u l=0.150u
M66 DI 6 VPWR VPWR pmos w=0.840u l=0.150u
M67 DI 6 VPWR VPWR pmos w=0.840u l=0.150u
M68 gnd2 4 YPAD VGND nmos w=0.420u l=0.150u
M69 YPAD 4 gnd2 VGND nmos w=0.420u l=0.150u
M70 gnd2 4 YPAD VGND nmos w=0.420u l=0.150u
M71 YPAD 4 gnd2 VGND nmos w=0.420u l=0.150u
M72 gnd2 4 YPAD VGND nmos w=0.420u l=0.150u
M73 YPAD 4 gnd2 VGND nmos w=0.420u l=0.150u
M74 gnd2 4 YPAD VGND nmos w=0.420u l=0.150u
M75 YPAD 4 gnd2 VGND nmos w=0.420u l=0.150u
M76 gnd2 4 YPAD VGND nmos w=0.420u l=0.150u
M77 YPAD 4 gnd2 VGND nmos w=0.420u l=0.150u
M78 gnd2 4 YPAD VGND nmos w=0.420u l=0.150u
M79 YPAD 4 gnd2 VGND nmos w=0.420u l=0.150u
R80 YPAD 5 100
R81 5 YPAD 100
.ends PADINC

.subckt PADINOUT VPWR VGND OEN DI YPAD DO
M0 vdd2 1 YPAD VPWR pmos w=0.840u l=0.150u
M1 YPAD 1 vdd2 VPWR pmos w=0.840u l=0.150u
M2 vdd2 1 YPAD VPWR pmos w=0.840u l=0.150u
M3 YPAD 1 vdd2 VPWR pmos w=0.840u l=0.150u
M4 vdd2 1 YPAD VPWR pmos w=0.840u l=0.150u
M5 YPAD 1 vdd2 VPWR pmos w=0.840u l=0.150u
M6 vdd2 1 YPAD VPWR pmos w=0.840u l=0.150u
M7 YPAD 1 vdd2 VPWR pmos w=0.840u l=0.150u
M8 vdd2 1 YPAD VPWR pmos w=0.840u l=0.150u
M9 YPAD 1 vdd2 VPWR pmos w=0.840u l=0.150u
M10 vdd2 1 YPAD VPWR pmos w=0.840u l=0.150u
M11 YPAD 1 vdd2 VPWR pmos w=0.840u l=0.150u
M12 2 OEN VGND VGND nmos w=0.420u l=0.150u
M13 3 2 VGND VGND nmos w=0.420u l=0.150u
M14 4 DO VGND VGND nmos w=0.420u l=0.150u
M15 4 DO VGND VGND nmos w=0.420u l=0.150u
M16 4 DO VGND VGND nmos w=0.420u l=0.150u
M17 4 DO VGND VGND nmos w=0.420u l=0.150u
M18 4 DO VGND VGND nmos w=0.420u l=0.150u
M19 4 2 VGND VGND nmos w=0.420u l=0.150u
M20 4 2 VGND VGND nmos w=0.420u l=0.150u
M21 4 2 VGND VGND nmos w=0.420u l=0.150u
M22 4 2 VGND VGND nmos w=0.420u l=0.150u
M23 4 2 VGND VGND nmos w=0.420u l=0.150u
M24 1 3 4 VGND nmos w=0.420u l=0.150u
M25 4 3 1 VGND nmos w=0.420u l=0.150u
M26 1 3 4 VGND nmos w=0.420u l=0.150u
M27 4 3 1 VGND nmos w=0.420u l=0.150u
M28 6 5 VGND VGND nmos w=0.420u l=0.150u
M29 6 5 VGND VGND nmos w=0.420u l=0.150u
M30 6 5 VGND VGND nmos w=0.420u l=0.150u
M31 6 5 VGND VGND nmos w=0.420u l=0.150u
M32 6 5 VGND VGND nmos w=0.420u l=0.150u
M33 6 5 VGND VGND nmos w=0.420u l=0.150u
M34 DI 6 VGND VGND nmos w=0.420u l=0.150u
M35 DI 6 VGND VGND nmos w=0.420u l=0.150u
M36 DI 6 VGND VGND nmos w=0.420u l=0.150u
M37 DI 6 VGND VGND nmos w=0.420u l=0.150u
M38 DI 6 VGND VGND nmos w=0.420u l=0.150u
M39 DI 6 VGND VGND nmos w=0.420u l=0.150u
M40 2 OEN VPWR VPWR pmos w=0.840u l=0.150u
M41 3 2 VPWR VPWR pmos w=0.840u l=0.150u
M42 1 DO VPWR VPWR pmos w=0.840u l=0.150u
M43 1 DO VPWR VPWR pmos w=0.840u l=0.150u
M44 1 DO VPWR VPWR pmos w=0.840u l=0.150u
M45 1 DO VPWR VPWR pmos w=0.840u l=0.150u
M46 1 DO VPWR VPWR pmos w=0.840u l=0.150u
M47 1 3 VPWR VPWR pmos w=0.840u l=0.150u
M48 1 3 VPWR VPWR pmos w=0.840u l=0.150u
M49 1 3 VPWR VPWR pmos w=0.840u l=0.150u
M50 1 3 VPWR VPWR pmos w=0.840u l=0.150u
M51 1 3 VPWR VPWR pmos w=0.840u l=0.150u
M52 4 2 1 VPWR pmos w=0.840u l=0.150u
M53 1 2 4 VPWR pmos w=0.840u l=0.150u
M54 4 2 1 VPWR pmos w=0.840u l=0.150u
M55 1 2 4 VPWR pmos w=0.840u l=0.150u
M56 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M57 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M58 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M59 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M60 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M61 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M62 DI 6 VPWR VPWR pmos w=0.840u l=0.150u
M63 DI 6 VPWR VPWR pmos w=0.840u l=0.150u
M64 DI 6 VPWR VPWR pmos w=0.840u l=0.150u
M65 DI 6 VPWR VPWR pmos w=0.840u l=0.150u
M66 DI 6 VPWR VPWR pmos w=0.840u l=0.150u
M67 DI 6 VPWR VPWR pmos w=0.840u l=0.150u
M68 gnd2 4 YPAD VGND nmos w=0.420u l=0.150u
M69 YPAD 4 gnd2 VGND nmos w=0.420u l=0.150u
M70 gnd2 4 YPAD VGND nmos w=0.420u l=0.150u
M71 YPAD 4 gnd2 VGND nmos w=0.420u l=0.150u
M72 gnd2 4 YPAD VGND nmos w=0.420u l=0.150u
M73 YPAD 4 gnd2 VGND nmos w=0.420u l=0.150u
M74 gnd2 4 YPAD VGND nmos w=0.420u l=0.150u
M75 YPAD 4 gnd2 VGND nmos w=0.420u l=0.150u
M76 gnd2 4 YPAD VGND nmos w=0.420u l=0.150u
M77 YPAD 4 gnd2 VGND nmos w=0.420u l=0.150u
M78 gnd2 4 YPAD VGND nmos w=0.420u l=0.150u
M79 YPAD 4 gnd2 VGND nmos w=0.420u l=0.150u
R80 YPAD 5 100
R81 5 YPAD 100
.ends PADINOUT

.subckt PADOUT VPWR VGND YPAD DO
M0 vdd2 1 YPAD VPWR pmos w=0.840u l=0.150u
M1 YPAD 1 vdd2 VPWR pmos w=0.840u l=0.150u
M2 vdd2 1 YPAD VPWR pmos w=0.840u l=0.150u
M3 YPAD 1 vdd2 VPWR pmos w=0.840u l=0.150u
M4 vdd2 1 YPAD VPWR pmos w=0.840u l=0.150u
M5 YPAD 1 vdd2 VPWR pmos w=0.840u l=0.150u
M6 vdd2 1 YPAD VPWR pmos w=0.840u l=0.150u
M7 YPAD 1 vdd2 VPWR pmos w=0.840u l=0.150u
M8 vdd2 1 YPAD VPWR pmos w=0.840u l=0.150u
M9 YPAD 1 vdd2 VPWR pmos w=0.840u l=0.150u
M10 vdd2 1 YPAD VPWR pmos w=0.840u l=0.150u
M11 YPAD 1 vdd2 VPWR pmos w=0.840u l=0.150u
M12 2 VPWR VGND VGND nmos w=0.420u l=0.150u
M13 3 2 VGND VGND nmos w=0.420u l=0.150u
M14 4 DO VGND VGND nmos w=0.420u l=0.150u
M15 4 DO VGND VGND nmos w=0.420u l=0.150u
M16 4 DO VGND VGND nmos w=0.420u l=0.150u
M17 4 DO VGND VGND nmos w=0.420u l=0.150u
M18 4 DO VGND VGND nmos w=0.420u l=0.150u
M19 4 2 VGND VGND nmos w=0.420u l=0.150u
M20 4 2 VGND VGND nmos w=0.420u l=0.150u
M21 4 2 VGND VGND nmos w=0.420u l=0.150u
M22 4 2 VGND VGND nmos w=0.420u l=0.150u
M23 4 2 VGND VGND nmos w=0.420u l=0.150u
M24 1 3 4 VGND nmos w=0.420u l=0.150u
M25 4 3 1 VGND nmos w=0.420u l=0.150u
M26 1 3 4 VGND nmos w=0.420u l=0.150u
M27 4 3 1 VGND nmos w=0.420u l=0.150u
M28 6 5 VGND VGND nmos w=0.420u l=0.150u
M29 6 5 VGND VGND nmos w=0.420u l=0.150u
M30 6 5 VGND VGND nmos w=0.420u l=0.150u
M31 6 5 VGND VGND nmos w=0.420u l=0.150u
M32 6 5 VGND VGND nmos w=0.420u l=0.150u
M33 6 5 VGND VGND nmos w=0.420u l=0.150u
M34 7 6 VGND VGND nmos w=0.420u l=0.150u
M35 7 6 VGND VGND nmos w=0.420u l=0.150u
M36 7 6 VGND VGND nmos w=0.420u l=0.150u
M37 7 6 VGND VGND nmos w=0.420u l=0.150u
M38 7 6 VGND VGND nmos w=0.420u l=0.150u
M39 7 6 VGND VGND nmos w=0.420u l=0.150u
M40 2 VPWR VPWR VPWR pmos w=0.840u l=0.150u
M41 3 2 VPWR VPWR pmos w=0.840u l=0.150u
M42 1 DO VPWR VPWR pmos w=0.840u l=0.150u
M43 1 DO VPWR VPWR pmos w=0.840u l=0.150u
M44 1 DO VPWR VPWR pmos w=0.840u l=0.150u
M45 1 DO VPWR VPWR pmos w=0.840u l=0.150u
M46 1 DO VPWR VPWR pmos w=0.840u l=0.150u
M47 1 3 VPWR VPWR pmos w=0.840u l=0.150u
M48 1 3 VPWR VPWR pmos w=0.840u l=0.150u
M49 1 3 VPWR VPWR pmos w=0.840u l=0.150u
M50 1 3 VPWR VPWR pmos w=0.840u l=0.150u
M51 1 3 VPWR VPWR pmos w=0.840u l=0.150u
M52 4 2 1 VPWR pmos w=0.840u l=0.150u
M53 1 2 4 VPWR pmos w=0.840u l=0.150u
M54 4 2 1 VPWR pmos w=0.840u l=0.150u
M55 1 2 4 VPWR pmos w=0.840u l=0.150u
M56 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M57 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M58 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M59 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M60 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M61 6 5 VPWR VPWR pmos w=0.840u l=0.150u
M62 7 6 VPWR VPWR pmos w=0.840u l=0.150u
M63 7 6 VPWR VPWR pmos w=0.840u l=0.150u
M64 7 6 VPWR VPWR pmos w=0.840u l=0.150u
M65 7 6 VPWR VPWR pmos w=0.840u l=0.150u
M66 7 6 VPWR VPWR pmos w=0.840u l=0.150u
M67 7 6 VPWR VPWR pmos w=0.840u l=0.150u
M68 gnd2 4 YPAD VGND nmos w=0.420u l=0.150u
M69 YPAD 4 gnd2 VGND nmos w=0.420u l=0.150u
M70 gnd2 4 YPAD VGND nmos w=0.420u l=0.150u
M71 YPAD 4 gnd2 VGND nmos w=0.420u l=0.150u
M72 gnd2 4 YPAD VGND nmos w=0.420u l=0.150u
M73 YPAD 4 gnd2 VGND nmos w=0.420u l=0.150u
M74 gnd2 4 YPAD VGND nmos w=0.420u l=0.150u
M75 YPAD 4 gnd2 VGND nmos w=0.420u l=0.150u
M76 gnd2 4 YPAD VGND nmos w=0.420u l=0.150u
M77 YPAD 4 gnd2 VGND nmos w=0.420u l=0.150u
M78 gnd2 4 YPAD VGND nmos w=0.420u l=0.150u
M79 YPAD 4 gnd2 VGND nmos w=0.420u l=0.150u
R80 YPAD 5 100
R81 5 YPAD 100
.ends PADOUT

.subckt TBUFX1 VPWR VGND EN A Y
M0 1 EN VPWR VPWR pmos w=0.840u l=0.150u
M1 2 1 Y VPWR pmos w=0.840u l=0.150u
M2 2 A VPWR VPWR pmos w=0.840u l=0.150u
M3 1 EN VGND VGND nmos w=0.420u l=0.150u
M4 3 EN Y VGND nmos w=0.420u l=0.150u
M5 3 A VGND VGND nmos w=0.420u l=0.150u
.ends TBUFX1

.subckt TBUFX2 VPWR VGND EN A Y
M0 1 EN VPWR VPWR pmos w=0.840u l=0.150u
M1 Y 1 2 VPWR pmos w=0.840u l=0.150u
M2 2 1 Y VPWR pmos w=0.840u l=0.150u
M3 2 A VPWR VPWR pmos w=0.840u l=0.150u
M4 2 A VPWR VPWR pmos w=0.840u l=0.150u
M5 1 EN VGND VGND nmos w=0.420u l=0.150u
M6 Y EN 3 VGND nmos w=0.420u l=0.150u
M7 3 EN Y VGND nmos w=0.420u l=0.150u
M8 3 A VGND VGND nmos w=0.420u l=0.150u
M9 3 A VGND VGND nmos w=0.420u l=0.150u
.ends TBUFX2

.subckt XNOR2X1 VPWR VGND B A Y
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 3 2 VPWR VPWR pmos w=0.840u l=0.150u
M2 Y 1 3 VPWR pmos w=0.840u l=0.150u
M3 4 A Y VPWR pmos w=0.840u l=0.150u
M4 4 B VPWR VPWR pmos w=0.840u l=0.150u
M5 2 B VPWR VPWR pmos w=0.840u l=0.150u
M6 1 A VGND VGND nmos w=0.420u l=0.150u
M7 5 2 VGND VGND nmos w=0.420u l=0.150u
M8 Y A 5 VGND nmos w=0.420u l=0.150u
M9 6 1 Y VGND nmos w=0.420u l=0.150u
M10 6 B VGND VGND nmos w=0.420u l=0.150u
M11 2 B VGND VGND nmos w=0.420u l=0.150u
.ends XNOR2X1

.subckt XOR2X1 VPWR VGND B A Y
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 3 2 VPWR VPWR pmos w=0.840u l=0.150u
M2 Y A 3 VPWR pmos w=0.840u l=0.150u
M3 4 1 Y VPWR pmos w=0.840u l=0.150u
M4 4 B VPWR VPWR pmos w=0.840u l=0.150u
M5 2 B VPWR VPWR pmos w=0.840u l=0.150u
M6 1 A VGND VGND nmos w=0.420u l=0.150u
M7 5 2 VGND VGND nmos w=0.420u l=0.150u
M8 Y 1 5 VGND nmos w=0.420u l=0.150u
M9 6 A Y VGND nmos w=0.420u l=0.150u
M10 6 B VGND VGND nmos w=0.420u l=0.150u
M11 2 B VGND VGND nmos w=0.420u l=0.150u
.ends XOR2X1
