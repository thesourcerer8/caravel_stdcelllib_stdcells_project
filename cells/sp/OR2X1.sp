*** Spice netlist generated by cell2spice.pl from cell file OR2X1.cell ***

.subckt OR2X1 VPWR VGND B A Y
M0 1 A 2 VPWR pmos w=0.840u l=0.150u
M1 1 B VPWR VPWR pmos w=0.840u l=0.150u
M2 Y 2 VPWR VPWR pmos w=0.840u l=0.150u
M3 2 A VGND VGND nmos w=0.420u l=0.150u
M4 2 B VGND VGND nmos w=0.420u l=0.150u
M5 Y 2 VGND VGND nmos w=0.420u l=0.150u
.ends OR2X1
