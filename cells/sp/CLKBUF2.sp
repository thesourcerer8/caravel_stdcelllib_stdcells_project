*** Spice netlist generated by cell2spice.pl from cell file CLKBUF2.cell ***

.subckt CLKBUF2 VPWR VGND A Y
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 1 A VPWR VPWR pmos w=0.840u l=0.150u
M2 2 1 VPWR VPWR pmos w=0.840u l=0.150u
M3 2 1 VPWR VPWR pmos w=0.840u l=0.150u
M4 3 2 VPWR VPWR pmos w=0.840u l=0.150u
M5 3 2 VPWR VPWR pmos w=0.840u l=0.150u
M6 4 3 VPWR VPWR pmos w=0.840u l=0.150u
M7 4 3 VPWR VPWR pmos w=0.840u l=0.150u
M8 5 4 VPWR VPWR pmos w=0.840u l=0.150u
M9 5 4 VPWR VPWR pmos w=0.840u l=0.150u
M10 Y 5 VPWR VPWR pmos w=0.840u l=0.150u
M11 Y 5 VPWR VPWR pmos w=0.840u l=0.150u
M12 1 A VGND VGND nmos w=0.420u l=0.150u
M13 1 A VGND VGND nmos w=0.420u l=0.150u
M14 2 1 VGND VGND nmos w=0.420u l=0.150u
M15 2 1 VGND VGND nmos w=0.420u l=0.150u
M16 3 2 VGND VGND nmos w=0.420u l=0.150u
M17 3 2 VGND VGND nmos w=0.420u l=0.150u
M18 4 3 VGND VGND nmos w=0.420u l=0.150u
M19 4 3 VGND VGND nmos w=0.420u l=0.150u
M20 5 4 VGND VGND nmos w=0.420u l=0.150u
M21 5 4 VGND VGND nmos w=0.420u l=0.150u
M22 Y 5 VGND VGND nmos w=0.420u l=0.150u
M23 Y 5 VGND VGND nmos w=0.420u l=0.150u
.ends CLKBUF2
