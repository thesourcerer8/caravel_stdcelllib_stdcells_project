*** Spice netlist generated by cell2spice.pl from cell file MUX2X1.cell ***

.subckt MUX2X1 VPWR VGND S B A Y
M0 1 S VPWR VPWR pmos w=0.840u l=0.150u
M1 2 B VPWR VPWR pmos w=0.840u l=0.150u
M2 Y S 2 VPWR pmos w=0.840u l=0.150u
M3 3 1 Y VPWR pmos w=0.840u l=0.150u
M4 3 A VPWR VPWR pmos w=0.840u l=0.150u
M5 1 S VGND VGND nmos w=0.420u l=0.150u
M6 4 B VGND VGND nmos w=0.420u l=0.150u
M7 Y 1 4 VGND nmos w=0.420u l=0.150u
M8 5 S Y VGND nmos w=0.420u l=0.150u
M9 5 A VGND VGND nmos w=0.420u l=0.150u
.ends MUX2X1
