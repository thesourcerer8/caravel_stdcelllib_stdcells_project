*** Spice netlist generated by cell2spice.pl from cell file MUX2X1.cell ***

.subckt MUX2X1 vdd gnd S B A Y
M0 1 S vdd vdd pmos w=0.840u l=0.150u
M1 2 B vdd vdd pmos w=0.840u l=0.150u
M2 Y S 2 vdd pmos w=0.840u l=0.150u
M3 3 1 Y vdd pmos w=0.840u l=0.150u
M4 3 A vdd vdd pmos w=0.840u l=0.150u
M5 1 S gnd gnd nmos w=0.420u l=0.150u
M6 4 B gnd gnd nmos w=0.420u l=0.150u
M7 Y 1 4 gnd nmos w=0.420u l=0.150u
M8 5 S Y gnd nmos w=0.420u l=0.150u
M9 5 A gnd gnd nmos w=0.420u l=0.150u
.ends MUX2X1
