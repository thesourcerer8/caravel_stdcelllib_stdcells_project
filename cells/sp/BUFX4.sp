*** Spice netlist generated by cell2spice.pl from cell file BUFX4.cell ***

.subckt BUFX4 vdd gnd A Y
M0 1 A vdd vdd pmos w=0.840u l=0.150u
M1 Y 1 vdd vdd pmos w=0.840u l=0.150u
M2 Y 1 vdd vdd pmos w=0.840u l=0.150u
M3 1 A gnd gnd nmos w=0.420u l=0.150u
M4 Y 1 gnd gnd nmos w=0.420u l=0.150u
M5 Y 1 gnd gnd nmos w=0.420u l=0.150u
.ends BUFX4
