*** Spice netlist generated by cell2spice.pl from cell file INVX8.cell ***

.subckt INVX8 vdd gnd A Y
M0 Y A vdd vdd pmos w=0.840u l=0.150u
M1 Y A vdd vdd pmos w=0.840u l=0.150u
M2 Y A vdd vdd pmos w=0.840u l=0.150u
M3 Y A vdd vdd pmos w=0.840u l=0.150u
M4 Y A gnd gnd nmos w=0.420u l=0.150u
M5 Y A gnd gnd nmos w=0.420u l=0.150u
M6 Y A gnd gnd nmos w=0.420u l=0.150u
M7 Y A gnd gnd nmos w=0.420u l=0.150u
.ends INVX8
