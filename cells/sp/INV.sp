*** Spice netlist generated by cell2spice.pl from cell file INV.cell ***

.subckt INV vdd gnd A Y
M0 Y A vdd vdd pmos w=0.840u l=0.150u
M1 Y A gnd gnd nmos w=0.420u l=0.150u
.ends INV
