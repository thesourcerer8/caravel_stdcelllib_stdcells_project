*** Spice netlist generated by cell2spice.pl from cell file AND2X2.cell ***

.subckt AND2X2 vdd gnd B A Y
M0 1 A vdd vdd pmos w=0.840u l=0.150u
M1 1 B vdd vdd pmos w=0.840u l=0.150u
M2 Y 1 vdd vdd pmos w=0.840u l=0.150u
M3 2 A 1 gnd nmos w=0.420u l=0.150u
M4 2 B gnd gnd nmos w=0.420u l=0.150u
M5 Y 1 gnd gnd nmos w=0.420u l=0.150u
.ends AND2X2
