*** Spice netlist generated by cell2spice.pl from cell file AND2X2.cell ***

.subckt AND2X2 VPWR VGND B A Y
M0 1 A VPWR VPWR pmos w=0.840u l=0.150u
M1 1 B VPWR VPWR pmos w=0.840u l=0.150u
M2 Y 1 VPWR VPWR pmos w=0.840u l=0.150u
M3 2 A 1 VGND nmos w=0.420u l=0.150u
M4 2 B VGND VGND nmos w=0.420u l=0.150u
M5 Y 1 VGND VGND nmos w=0.420u l=0.150u
.ends AND2X2
