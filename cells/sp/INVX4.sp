*** Spice netlist generated by cell2spice.pl from cell file INVX4.cell ***

.subckt INVX4 vdd gnd A Y
M0 Y A vdd vdd pmos w=0.840u l=0.150u
M1 Y A vdd vdd pmos w=0.840u l=0.150u
M2 Y A gnd gnd nmos w=0.420u l=0.150u
M3 Y A gnd gnd nmos w=0.420u l=0.150u
.ends INVX4
