*** Spice netlist generated by cell2spice.pl from cell file INVX4.cell ***

.subckt INVX4 VPWR VGND A Y
M0 Y A VPWR VPWR pmos w=0.840u l=0.150u
M1 Y A VPWR VPWR pmos w=0.840u l=0.150u
M2 Y A VGND VGND nmos w=0.420u l=0.150u
M3 Y A VGND VGND nmos w=0.420u l=0.150u
.ends INVX4
