*** Spice netlist generated by cell2spice.pl from cell file AOI22X1.cell ***

.subckt AOI22X1 vdd gnd D C B A Y
M0 1 A vdd vdd pmos w=0.840u l=0.150u
M1 1 B vdd vdd pmos w=0.840u l=0.150u
M2 Y D 1 vdd pmos w=0.840u l=0.150u
M3 1 C Y vdd pmos w=0.840u l=0.150u
M4 2 A gnd gnd nmos w=0.420u l=0.150u
M5 Y B 2 gnd nmos w=0.420u l=0.150u
M6 3 D Y gnd nmos w=0.420u l=0.150u
M7 3 C gnd gnd nmos w=0.420u l=0.150u
.ends AOI22X1
