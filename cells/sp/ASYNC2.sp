*** Spice netlist generated by cell2spice.pl from cell file ASYNC2.cell ***

.subckt ASYNC2 VPWR VGND A B C CN
M0 CN C GND VGND nmos w=0.420u l=0.150u
M1 net1 A VDD VPWR pmos w=0.840u l=0.150u
M2 CN B net1 VPWR pmos w=0.840u l=0.150u
M3 C CN VDD VPWR pmos w=0.840u l=0.150u
M4 CN C VDD VPWR pmos w=0.840u l=0.150u
M5 CN B net2 VGND nmos w=0.420u l=0.150u
M6 net2 A GND VGND nmos w=0.420u l=0.150u
M7 C CN GND VGND nmos w=0.420u l=0.150u
.ends ASYNC2
